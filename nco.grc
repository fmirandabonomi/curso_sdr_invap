options:
  parameters:
    generate_options: qt_gui
    id: nco
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: frec
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    label: Frecuencia
    start: '0'
    step: samp_rate/1024
    stop: samp_rate/2
    value: '0'
  states: {}
- name: nbits_tabla
  id: variable
  parameters:
    value: '16'
  states: {state: disabled}
- name: nbits_tabla
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: Nr bits tabla coseno
    rangeType: int
    start: '4'
    step: '1'
    stop: '31'
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: 2**(31-nbits_tabla)
    type: int
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: 2**31-1
    freq: frec
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: int
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: int
  states: {}
- name: blocks_int_to_float_1
  id: blocks_int_to_float
  parameters:
    scale: (2**nbits_tabla)/(2*np.pi)
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: int
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: cos
    type: float
  states: {}
- name: channels_quantizer_0
  id: channels_quantizer
  parameters:
    bits: '16'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0
    size: '128'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_divide_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_divide_xx_0, '0', blocks_int_to_float_1, '0']
- [blocks_int_to_float_1, '0', blocks_transcendental_0, '0']
- [blocks_throttle_0, '0', blocks_divide_xx_0, '0']
- [blocks_transcendental_0, '0', channels_quantizer_0, '0']
- [channels_quantizer_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_quantizer_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
