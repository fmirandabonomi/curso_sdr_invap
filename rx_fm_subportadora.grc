options:
  parameters:
    author: Fernando
    generate_options: qt_gui
    id: rx_fm_subportadora
    output_language: python
    title: Receptor FM
  states: {}

blocks:
- name: Fol
  id: variable
  parameters:
    value: (sintonia*1e6-freq)
  states: {}
- name: ancho_banda_fraccional
  id: variable
  parameters:
    value: '0.4'
  states: {}
- name: ancho_transicion
  id: variable
  parameters:
    value: (0.5-ancho_banda_fraccional)*tasa_fraccional
  states: {}
- name: freq
  id: variable
  parameters:
    value: (88+108)/2*1e6
  states: {}
- name: interpolacion
  id: variable
  parameters:
    value: '4'
  states: {}
- name: lpf
  id: variable_low_pass_filter_taps
  parameters:
    beta: '7'
    cutoff_freq: tasa_fraccional*0.5-ancho_transicion/2
    gain: interpolacion
    samp_rate: interpolacion
    width: ancho_transicion
    win: window.WIN_KAISER
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sintonia
  id: variable_qtgui_range
  parameters:
    label: Sintonía (MHz)
    start: '88'
    step: '0.05'
    stop: '108'
    value: '88'
  states: {}
- name: submuestreo
  id: variable
  parameters:
    value: '125'
  states: {}
- name: tasa_fraccional
  id: variable
  parameters:
    value: interpolacion/submuestreo
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '20'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: '640000'
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.8'
    freq: Fol
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_correctiq_auto_0
  id: blocks_correctiq_auto
  parameters:
    freq: freq
    gain: 24+16
    samp_rate: samp_rate
    syncWindow: '2'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 640e3
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    label1: '''Banda base'''
    label2: '''Oscilador local'''
    nconnections: '2'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '4'
    taps: lpf
    type: ccc
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: samp_rate
    center_freq: freq
    gain: '24'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', audio_sink_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_1, '1']
- [blocks_correctiq_auto_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_correctiq_auto_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_fm_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', blocks_correctiq_auto_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
