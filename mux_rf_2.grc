options:
  parameters:
    generate_options: qt_gui
    id: mux_rf_2
    output_language: python
    title: Simulació multiplexor de radiofrecuencia 2
  states: {}

blocks:
- name: frec_A
  id: variable
  parameters:
    value: (100+6100)/2
  states: {}
- name: frec_B
  id: variable
  parameters:
    value: (7050+13050)/2
  states: {}
- name: frec_C
  id: variable
  parameters:
    value: (14000+20000)/2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: taps
  id: variable
  parameters:
    value: 0.0005549183115363121,0.0004148974840063602,0.00012197808246128261,-0.00026113310013897717,-0.000631344155408442,-0.0008572356891818345,-0.0008126511820591986,-0.00042897596722468734,0.0002515400410629809,0.0010492696892470121,0.0016732531366869807,0.0018083220347762108,0.0012441271683201194,-1.8766254828796664e-18,-0.001612835912965238,-0.0030383195262402296,-0.0036418233066797256,-0.002955124480649829,-0.0009148952085524797,0.002008230658248067,0.004870313219726086,0.00652316166087985,0.006028134375810623,0.0030783035326749086,-0.0017387325642630458,-0.006974916439503431,-0.010699623264372349,-0.011142918840050697,-0.0074087041430175304,5.419873902675568e-18,0.009076451882719994,0.01674356497824192,0.019765866920351982,0.015899185091257095,0.004915719851851463,-0.010868444107472897,-0.0268192570656538,-0.037001412361860275,-0.035767510533332825,-0.019491342827677727,0.012073277495801449,0.05525784194469452,0.10300129652023315,0.14635732769966125,0.1766158640384674,0.1874687224626541,0.1766158640384674,0.14635732769966125,0.10300129652023315,0.05525784194469452,0.012073277495801449,-0.019491342827677727,-0.035767510533332825,-0.037001412361860275,-0.0268192570656538,-0.010868444107472897,0.004915719851851463,0.015899185091257095,0.019765866920351982,0.01674356497824192,0.009076451882719994,5.419873902675568e-18,-0.0074087041430175304,-0.011142918840050697,-0.010699623264372349,-0.006974916439503431,-0.0017387325642630458,0.0030783035326749086,0.006028134375810623,0.00652316166087985,0.004870313219726086,0.002008230658248067,-0.0009148952085524797,-0.002955124480649829,-0.0036418233066797256,-0.0030383195262402296,-0.001612835912965238,-1.8766254828796664e-18,0.0012441271683201194,0.0018083220347762108,0.0016732531366869807,0.0010492696892470121,0.0002515400410629809,-0.00042897596722468734,-0.0008126511820591986,-0.0008572356891818345,-0.000631344155408442,-0.00026113310013897717,0.00012197808246128261,0.0004148974840063602,0.0005549183115363121
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frec_A
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frec_B
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frec_C
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frec_B
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_2_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frec_C
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_2_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frec_A
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_1
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '3'
    taps: taps
    type: ccf
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '3'
    taps: taps
    type: ccf
  states: {}
- name: fir_filter_xxx_0_1
  id: fir_filter_xxx
  parameters:
    decim: '3'
    taps: taps
    type: ccf
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '3'
    taps: taps
    type: ccf
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '3'
    taps: taps
    type: ccf
  states: {}
- name: interp_fir_filter_xxx_0_1
  id: interp_fir_filter_xxx
  parameters:
    interp: '3'
    taps: taps
    type: ccf
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0
    name: Espectro Entrada
    type: float
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1
    name: '"Salida"'
    type: float
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,0,1,2
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_conjugate_cc_0_1, '1']
- [analog_sig_source_x_0_2, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_2_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_2_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '0', qtgui_freq_sink_x_0, '0']
- [audio_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_conjugate_cc_0_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_multiply_conjugate_cc_0_1, '0', fir_filter_xxx_0_1, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_0_0, '0', blocks_add_xx_0, '2']
- [fir_filter_xxx_0, '0', interp_fir_filter_xxx_0, '0']
- [fir_filter_xxx_0_0, '0', interp_fir_filter_xxx_0_0, '0']
- [fir_filter_xxx_0_1, '0', interp_fir_filter_xxx_0_1, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_xx_0, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_multiply_xx_0_0, '0']
- [interp_fir_filter_xxx_0_1, '0', blocks_multiply_xx_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
